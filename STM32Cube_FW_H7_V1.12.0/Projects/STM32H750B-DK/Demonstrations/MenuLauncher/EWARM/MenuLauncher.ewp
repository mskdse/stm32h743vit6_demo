# IAR project MenuLauncher.ewp, settings and files
configuration MenuLauncher-STM32H750B-DK (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750B-DISCO ST STM32H750B-DISCO
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H750xx; USE_STM32H750B_DK; BSP_USE_CMSIS_OS; USE_PWR_LDO_SUPPLY; USE_TS_INT
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Gui\Target; ..\Gui\App; ..\Gui\App\generated; ..\Modules\splashscreen; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H750B-DK; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\ft6x06; ..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152; ..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: ..\Binary\MenuLauncher-STM32H750B-DK_V1.0.0.hex
  ILINK.IlinkOutputFile: MenuLauncher-STM32H750B-DK_V1.0.0.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08000000
  ILINK.IlinkIcfFile: stm32h7xx_FLASH.icf
  ILINK.IlinkExtraOptions: --image_input ..\Gui\App\assets\default_icon.bmp,default_icon,default_icon_section,32; --keep default_icon; --image_input ..\Gui\App\assets\default_logo.bmp,default_logo,default_logo_section,32; --keep default_logo; --image_input ..\Gui\App\assets\splash_st.avi,splash_st,splash_st_section,32; --keep splash_st
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: bsp.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c system_stm32h7xx.c
  group Application/User/Modules/SplashScreen
    ../Modules/splashscreen/: AVI_parser.c decode_dma.c splash.c
  group Application/User/STemWin
    ../Gui/App/: MenuLauncher.c
  group Application/User/STemWin/generated
    ../Gui/App/generated/: arrow_right.c background.c board_icon.c cpu_icon.c dialog_box.c firmware_icon.c info_icon.c info_screen.c LucidaSans14.c LucidaSans16.c LucidaSans20.c mcu_icon.c message_box.c pbar_bck.c reflect.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../../../../../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
  group Drivers/BSP/STM32H750B-DK
    ../../../../../Drivers/BSP/STM32H750B-DK/: stm32h750b_discovery.c stm32h750b_discovery_bus.c stm32h750b_discovery_qspi.c stm32h750b_discovery_sdram.c stm32h750b_discovery_ts.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc32_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
