# IAR project STemWin.ewp, settings and files
configuration STemWin-STM32H750B-DK_OoB (ARM)
  General.OGChipSelectEditMenu: STM32H750B-DISCO ST STM32H750B-DISCO
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_LDO_SUPPLY; USE_HAL_DRIVER; STM32H750xx; USE_STM32H750B_DK; BSP_USE_CMSIS_OS; USE_PWR_LDO_SUPPLY; VECT_TAB_QSPI; USE_TS_INT; USE_USB_FS
  ICCARM.CCIncludePath2: ..\Config; ..\Core\inc; ..\Gui\Core\video_player; ..\Gui\STemWin_Addons; ..\Gui\Target; ..\Modules\Common; ..\Modules\audio_player; ..\Modules\audio_player\Inc; ..\Modules\audio_player\App; ..\Modules\audio_player\Addons\Common\Inc; ..\Modules\audio_player\Addons\SRC236\Inc; ..\Modules\audio_player\Addons\SRC441\Inc; ..\Modules\video_player; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H750B-DK; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: ..\Binary\STemWin-STM32H750B-DK_OoB_V1.0.0.hex
  ILINK.IlinkOutputFile: STemWin-STM32H750B-DK_OoB_V1.0.0.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x90040000
  ILINK.IlinkIcfFile: stm32h7xx_STemWin.icf
  ILINK.IlinkExtraOptions: --image_input ..\Core\Src\assets\stemwin_icon.bmp,demo_icon,demo_icon_section,32; --keep demo_icon; --image_input ..\Core\Src\assets\stemwin_logo.bmp,demo_logo,demo_logo_section,32; --keep demo_logo; --diag_warning Lt009; --diag_suppress Lt009
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h750xx.s
  group Application/User/Core
    ../Core/Src/: k_bsp.c k_menu.c k_module.c k_rtc.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage.c system_stm32h7xx.c
    ../Config/: usbh_conf.c
  group Application/User/Gui/analog_clock
    ../Gui/Core/analog_clock/: analog_clock_win.c
  group Application/User/Gui/analog_clock/generated
    ../Gui/Core/analog_clock/generated/: analog_clock_res.c filter.c
  group Application/User/Gui/analog_clock/generated/alarm
    ../Gui/Core/analog_clock/generated/alarm/: Clock1_anim_1.c Clock1_anim_2.c Clock1_anim_3.c Clock2_anim_1.c Clock2_anim_2.c Clock2_anim_3.c Clock3_anim_1.c Clock3_anim_2.c Clock3_anim_3.c LABEL_head.c shap_alarm.c
  group Application/User/Gui/analog_clock/generated/clocks
    ../Gui/Core/analog_clock/generated/clocks/: Clock1.c Clock1_small.c Clock2.c Clock2_small.c Clock3.c Clock3_small.c
  group Application/User/Gui/analog_clock/generated/controls
    ../Gui/Core/analog_clock/generated/controls/: alarm_icon_res.c next_arrow.c plus_alarm_res.c settings_button_res.c settings_icon_res.c
  group Application/User/Gui/analog_clock/generated/weather
    ../Gui/Core/analog_clock/generated/weather/: weather_cloud_rain_res.c weather_cloud_res.c weather_cloud_sun_res.c weather_cloud_thunder_res.c weather_cloud_thunder_sun_res.c weather_shape_res.c weather_sun_res.c
  group Application/User/Gui/audio_player
    ../Gui/Core/audio_player/: audio_player_win.c visualization.c
  group Application/User/Gui/audio_player/generated
    ../Gui/Core/audio_player/: audio_player_res.c
  group Application/User/Gui/games
    ../Gui/Core/games/: rocket_game_win.c
  group Application/User/Gui/games/generated
    ../Gui/Core/games/generated/: background_game.c circle.c main_menu.c
  group Application/User/Gui/games/generated/coins
    ../Gui/Core/games/generated/coins/: coin1.c coin10.c coin11.c coin12.c coin13.c coin2.c coin3.c coin4.c coin5.c coin6.c coin7.c coin8.c coin9.c
  group Application/User/Gui/games/generated/gameover_screen
    ../Gui/Core/games/generated/gameover_screen/: game_over.c replay_button.c rocket_down1_game_over.c rocket_down2_game_over.c rocket_down_game_over.c score.c score_shape_game_over.c
  group Application/User/Gui/games/generated/objects
    ../Gui/Core/games/generated/objects/: comet.c moon.c planet1.c planet2.c planet3.c
  group Application/User/Gui/games/generated/parallax
    ../Gui/Core/games/generated/parallax/: mountains1.c mountains2.c mountains3.c sky1.c sky2.c
  group Application/User/Gui/games/generated/play_screen
    ../Gui/Core/games/generated/play_screen/: game_title.c play_button.c
  group Application/User/Gui/games/generated/rocket
    ../Gui/Core/games/generated/rocket/: rocket.c
  group Application/User/Gui/games/generated/score
    ../Gui/Core/games/generated/score/: goldCoin.c scoreShape.c
  group Application/User/Gui/generated
    ../Core/Src/generated/: Arial18.c ArialRoundedBold18.c ArialRoundedBold20.c ArialRoundedBold24.c
  group Application/User/Gui/generated/menu
    ../Core/Src/: k_modules_res.c
  group Application/User/Gui/generated/menu/clicked
    ../Core/Src/generated/menu/clicked/: audio_player_clicked.c clock_date_clicked.c graphic_effects_clicked.c video_game_clicked.c video_player_clicked.c
  group Application/User/Gui/generated/menu/idle
    ../Core/Src/generated/menu/idle/: audio_player_idle.c clock_date_idle.c graphic_effects_idle.c video_game_idle.c video_player_idle.c
  group Application/User/Gui/graphic_effect
    ../Gui/Core/graphic_effect/: fatfs_storage.c filtring.c graphic_effects_win.c
  group Application/User/Gui/graphic_effect/generated
    ../Gui/Core/graphic_effect/generated/buttons/: apply_filter.c apply_filter_pressed.c cpu_load_background.c edge_detection.c edge_detection_gray.c motion_blur.c motion_blur_gray.c next.c next_gray.c next_pressed.c previous.c previous_gray.c previous_pressed.c raising.c raising_gray.c reset.c reset_gray.c reset_pressed.c sharpening.c sharpening_gray.c smoothing.c smoothing_gray.c
    ../Gui/Core/graphic_effect/: graphic_effects_res.c
  group Application/User/Gui/settings
    ../Gui/Core/settings/: settings_win.c
  group Application/User/Gui/settings/generated
    ../Gui/Core/settings/generated/: Board.c Chip.c Firmware.c Speed.c
  group Application/User/Gui/video_player
    ../Gui/Core/video_player/: jpeg_utils.c video_player_win.c
  group Application/User/Gui/video_player/generated
    ../Gui/Core/video_player/: video_player_res.c
  group Application/User/Modules/audio_player/Addons/SRC236
    ../Modules/audio_player/Addons/SRC236/Lib/: SRC236HQ_CM7_IAR.a
  group Application/User/Modules/audio_player/Addons/SRC441
    ../Modules/audio_player/Addons/SRC441/Lib/: SRC441HQ_CM7_IAR.a
  group Application/User/Modules/audio_player/App
    ../Modules/audio_player/App/: audio_player_app.c
  group Application/User/Modules/audio_player/Player
    ../Modules/audio_player/Src/: aviprocess.c coders.c fwkmempool.c player.c songutilities.c wavprocess.c
  group Application/User/Modules/video_player
    ../Modules/video_player/: GUI_AVI.c video_player_app.c
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
  group Drivers/BSP/STM32H750B-DK
    ../../../../../Drivers/BSP/STM32H750B-DK/: stm32h750b_discovery.c stm32h750b_discovery_audio.c stm32h750b_discovery_bus.c stm32h750b_discovery_sdram.c stm32h750b_discovery_ts.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Core/Src/: usbh_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc32_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STemWin_Addons_CM7_wc32.a
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
