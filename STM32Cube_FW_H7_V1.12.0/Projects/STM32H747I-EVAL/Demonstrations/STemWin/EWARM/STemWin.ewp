# IAR project STemWin.ewp, settings and files
configuration STemWin-STM32H747I-EVAL_OoB (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_EVAL; USE_STM32H747I_EVAL_OOB; USE_IOEXPANDER; CORE_CM7; BSP_USE_CMSIS_OS; DEBUG_HW_JPEG__N; USE_SDCARD; USE_USB_HS
  ICCARM.CCIncludePath2: ..\Gui\STemWin_Addons; ..\Config; ..\Core\inc; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H747I-EVAL; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\otm8009a; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\Modules\Common; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\Gui\Target; ..\Gui\Core\video_player; ..\Modules\audio_player; ..\Modules\audio_player\Inc; ..\Modules\audio_player\App; ..\Modules\audio_player\Addons\Common\Inc; ..\Modules\audio_player\Addons\SRC236\Inc; ..\Modules\audio_player\Addons\SRC441\Inc; ..\Modules\video_player; ..\Modules\dual_core; ..\..\extra_modules\STIPC\Core\Common\Inc; ..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: ..\Binary\STemWin-STM32H747I-EVAL_OoB_V1.0.0.hex
  ILINK.IlinkOutputFile: STemWin-STM32H747I-EVAL_OoB_V1.0.0.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08040000
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkExtraOptions: --image_input ..\Core\Src\assets\stemwin_icon.bmp,demo_icon,demo_icon_section,8; --keep demo_icon; --image_input ..\Core\Src\assets\stemwin_logo.bmp,demo_logo,demo_logo_section,8; --keep demo_logo; --diag_warning Lt009; --diag_suppress Lt009
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STemWin-STM32H747I-EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H747xx; USE_STM32H747I_EVAL; USE_PWR_LDO_SUPPLY__N; USE_IOEXPANDER; CORE_CM7; BSP_USE_CMSIS_OS; DEBUG_HW_JPEG__N; USE_SDCARD; USE_USB_HS
  ICCARM.CCIncludePath2: ..\Gui\STemWin_Addons; ..\Config; ..\Core\inc; ..\..\..\..\..\Utilities\CPU; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H747I-EVAL; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\otm8009a; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\Third_Party\LwIP\src\include\; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system; ..\..\..\..\..\Middlewares\Third_Party\LwIP\system\OS; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc; ..\Modules\Common; ..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc; ..\Gui\Target; ..\Gui\Core\video_player; ..\Modules\audio_player; ..\Modules\audio_player\Inc; ..\Modules\audio_player\App; ..\Modules\audio_player\Addons\Common\Inc; ..\Modules\audio_player\Addons\SRC236\Inc; ..\Modules\audio_player\Addons\SRC441\Inc; ..\Modules\video_player; ..\Modules\dual_core; ..\..\extra_modules\STIPC\Core\Common\Inc; ..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: ..\Binary\STemWin-STM32H747I-EVAL_V1.0.0.hex
  ILINK.IlinkOutputFile: STemWin-STM32H747I-EVAL_V1.0.0.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08000000
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h747xx.s
  group Application/User/Core
    ../../extra_modules/STIPC/Core/Common/Src/: cm_ipc.c
    ../Core/Src/: k_bsp.c k_calibration.c k_menu.c k_mfx.c k_module.c k_rtc.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage.c system_stm32h7xx.c
    ../Config/: usbh_conf.c
  group Application/User/Gui/analog_clock
    ../Gui/Core/anolog_clock/: analog_clock_win.c
    ../Gui/Core/anolog_clock/generated/: Arial32.c
  group Application/User/Gui/audio_player
    ../Gui/Core/audio_player/: audio_player_win.c visualization.c
  group Application/User/Gui/dual_core
    ../Gui/Core/dual_core/: dual_core_win.c
  group Application/User/Gui/games
    ../Gui/Core/games/: rocket_game_win.c
  group Application/User/Gui/graphic_effect
    ../Gui/Core/graphic_effect/: fatfs_storage.c filtring.c graphic_effects_win.c
  group Application/User/Gui/settings
    ../Gui/Core/settings/: settings_win.c
  group Application/User/Gui/video_player
    ../Gui/Core/video_player/: jpeg_utils.c video_player_win.c
  group Application/User/Modules/audio_player/Addons/SRC236
    ../Modules/audio_player/Addons/SRC236/Lib/: SRC236HQ_CM7_IAR.a
  group Application/User/Modules/audio_player/Addons/SRC441
    ../Modules/audio_player/Addons/SRC441/Lib/: SRC441HQ_CM7_IAR.a
  group Application/User/Modules/audio_player/App
    ../Modules/audio_player/App/: audio_player_app.c
  group Application/User/Modules/audio_player/Player
    ../Modules/audio_player/Src/: aviprocess.c coders.c fwkmempool.c player.c songutilities.c wavprocess.c
  group Application/User/Modules/dual_core
    ../Modules/dual_core/: GUI_AVI_2.c video_player_app_2.c
  group Application/User/Modules/video_player
    ../Modules/video_player/: GUI_AVI.c video_player_app.c
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Component
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
    ../../../../../Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
  group Drivers/BSP/STemWin-STM32H747I-EVAL
    ../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_audio.c stm32h747i_eval_bus.c stm32h747i_eval_io.c stm32h747i_eval_qspi.c stm32h747i_eval_sd.c stm32h747i_eval_sdram.c stm32h747i_eval_ts.c
  group Drivers/STM32H7xx_HAL_Drivers
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Config/: sd_diskio.c sd_diskio_dma.c sd_diskio_dma_rtos.c usbh_diskio.c usbh_diskio_dma.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_IAR_wc32.a
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc32_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STemWin_Addons_CM7_wc32.a
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
