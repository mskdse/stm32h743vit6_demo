# IAR project MenuLauncher.ewp, settings and files
configuration MenuLauncher-STM32H747I-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32H747XI_CM7 ST STM32H747XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H747xx; MPU_DISABLE_CACHE__N; QSPI_LOW_FREQ__N; USE_STM32H747I_EVAL; USE_PWR_LDO_SUPPLY__N; USE_TS_INT; USE_SDCARD; USE_USB_HS; CORE_CM7
  ICCARM.CCIncludePath2: ..\Core\Common\Inc; ..\Core\CM7\Inc; ..\Gui\Target; ..\Gui\STemWin_Addons; ..\Gui\App; ..\Gui\App\generated; ..\Modules\splashscreen; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H747I-EVAL; ..\..\..\..\..\Drivers\BSP\Components\otm8009a; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Drivers\BSP\Components\ft6x06; ..\..\..\..\..\Drivers\BSP\Components\mfxstm32l152; ..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\CM7\Inc
  OBJCOPY.OOCOutputFile: ..\Binary\MenuLauncher-STM32H747I-EVAL_V1.1.0.hex
  ILINK.IlinkOutputFile: MenuLauncher.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08000000
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkExtraOptions: --image_input ..\Gui\App\assets\default_icon.bmp,default_icon,default_icon_section,8; --keep default_icon; --image_input ..\Gui\App\assets\default_logo.bmp,default_logo,default_logo_section,8; --keep default_logo; --image_input ..\Gui\App\assets\splash_st.avi,splash_st,splash_st_section,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h747xx.s
  group Application/User/Core/CM7
    ../Core/CM7/Src/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/Core/Common
    ../Core/Common/Src/: bsp.c calibration.c mfx.c stm32h7xx_hal_msp.c storage.c usbh_conf.c
  group Application/User/Modules/SplashScreen
    ../Modules/splashscreen/: AVI_parser.c decode_dma.c splash.c
  group Application/User/STemWin
    ../Gui/App/: MenuLauncher.c
  group Application/User/STemWin/generated
    ../Gui/App/generated/: arrow_right.c background.c board_icon.c cpu_icon.c dialog_box.c firmware_icon.c info_icon.c info_screen.c LucidaSans18.c LucidaSans25.c LucidaSans30.c mcu_icon.c message_box.c pbar_bck.c reflect.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
  group Drivers/BSP/STM32H747I_EVAL
    ../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_bus.c stm32h747i_eval_io.c stm32h747i_eval_qspi.c stm32h747i_eval_sd.c stm32h747i_eval_sdram.c stm32h747i_eval_ts.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Core/Common/Src/: sd_diskio_dma.c usbh_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc32_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
