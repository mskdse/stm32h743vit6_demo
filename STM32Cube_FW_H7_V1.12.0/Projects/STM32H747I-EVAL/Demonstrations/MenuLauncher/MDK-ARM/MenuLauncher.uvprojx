# Keil uVision project MenuLauncher.uvprojx, settings and files
target MenuLauncher-STM32H747I-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H747XIHx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.6
  cpu: IROM_ML(0x08000000-0x803FFFF) IROM_STEW(0x08040000-0x809FFFF) IROM_EWIZ(0x080A0000-0x80FFFFF) IROM_STFW(0x08100000-0x813FFFF) IROM_TGFX(0x08140000-0x81DFFFF) IROM_CUC(0x081E0000-0x81FFFFF) IRAM2(0x00000000-0xFFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x24000000-0x2407FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: MenuLauncher-STM32H747I-EVAL_V1.0.0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H747xx,USE_STM32H747I_EVAL,USE_PWR_LDO_SUPPLY__N,USE_IOEXPANDER,USE_TS_INT,USE_SDCARD,USE_USB_HS,CORE_CM7
  c include: ../Core/Common/Inc;../Core/CM7/Inc;../Gui/Target;../Gui/STemWin_Addons;../Gui/App;../Gui/App/generated;../Modules/splashscreen;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32H747I-EVAL;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/ft6x06;../../../../../Drivers/BSP/Components/mfxstm32l152;../../../../../Middlewares/ST/STemWin/inc;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;../../../../../Drivers/BSP/Components/otm8009a
  asm include: ../Core/CM7/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: MenuLauncher-STM32H747I-EVAL\Exe\MenuLauncher-STM32H747I-EVAL_V1.0.sct
  link misc: --keep *(default_icon_section)
--keep *(default_logo_section)
  group Application/MDK-ARM
    ./: startup_stm32h747xx.s
    ./: Media.s
  group Application/User/Core/CM7
    ../Core/CM7/Src/: main.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/Core/Common
    ../Core/Common/Src/: bsp.c calibration.c mfx.c stm32h7xx_hal_msp.c storage.c usbh_conf.c
  group Application/User/Modules/SplashScreen
    ../Modules/splashscreen/: AVI_parser.c decode_dma.c splash.c
  group Application/User/STemWin
    ../Gui/App/: MenuLauncher.c
  group Application/User/STemWin/generated
    ../Gui/App/generated/: arrow_right.c background.c board_icon.c cpu_icon.c dialog_box.c firmware_icon.c info_icon.c info_screen.c LucidaSans18.c LucidaSans25.c LucidaSans30.c mcu_icon.c message_box.c pbar_bck.c reflect.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft6x06/: ft6x06.c ft6x06_reg.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/otm8009a/: otm8009a.c otm8009a_reg.c
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../../../Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
  group Drivers/BSP/STM32H747I_EVAL
    ../../../../../Drivers/BSP/STM32H747I-EVAL/: stm32h747i_eval.c stm32h747i_eval_bus.c stm32h747i_eval_io.c stm32h747i_eval_qspi.c stm32h747i_eval_sd.c stm32h747i_eval_sdram.c stm32h747i_eval_ts.c
  group Drivers/CMSIS
    ../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_exti.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Core/Common/Src/: sd_diskio_dma.c usbh_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc16_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/STM32_USBH_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
software components: CMSIS:CORE 5.1.2
