# IAR project Project.ewp, settings and files
configuration STM32H745I_DISCO_CM7 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H745XI_CM7 ST STM32H745XI_CM7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H745xx; USE_STM32H745I_DISCO; CORE_CM7
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM7\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32H745I-DISCO; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\..\Utilities; ..\..\..\..\..\..\Utilities\Fonts
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H745I_DISCO_CM7.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32h7xx_CM7_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32H745I_DISCO_CM4 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H745XI_CM4 ST STM32H745XI_CM4
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H745xx; USE_STM32H745I_DISCO; CORE_CM4
  ICCARM.CCIncludePath2: ..\Common\Inc; ..\CM4\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc
  ILINK.IlinkIcfFile: stm32h7xx_CM4_FLASH.icf
  group Application/EWARM
    ./: startup_stm32h745xx.s
  group Application/User/CM4
    ../CM4/Src/: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c
  group Application/User/CM7
    ../CM7/Src/: BASIC_HelloWorld.c main.c stm32h7xx_it.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mt48lc4m32b2/: mt48lc4m32b2.c
  group Drivers/BSP/STM32H745I_DISCOVERY
    ../../../../../../Drivers/BSP/STM32H745I-DISCO/: stm32h745i_discovery.c stm32h745i_discovery_sdram.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
  group Middlewares/STemWin/Config
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
    ../CM7/Src/: GUIConf.c LCDConf.c
  group Middlewares/STemWin/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_wc32.a
