# Keil uVision project ClockAndWeather.uvprojx, settings and files
target ClockAndWeather-STM32H735G-DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H735IGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00100000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00020000) XRAM2(0x38000000,0x00008000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ClockAndWeather +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H735xx,USE_STM32H735G_DK,USE_BPP=24,ST,USE_FLOATING_POINT,USE_SDCARD,RTC_CLOCK_SOURCE_LSE,USE_MXCHIP_MB1400
  c include: ../TouchGFX/generated/images/include;../TouchGFX/generated/fonts/include;../TouchGFX/generated/texts/include;../TouchGFX/generated/gui_generated/include;../TouchGFX/gui/include;../../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/STM32H735G-DK;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../../Middlewares/Third_Party/FatFs/src;../../../../../../Middlewares/Third_Party/FatFs/src/drivers;../Config;../Core/Inc;../../../../../../Drivers/CMSIS/Include;..;../TouchGFX/target;../TouchGFX/widgets;../JSON;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Middlewares/ST/STM32_Network_Library/Includes;../../../../../../Drivers/BSP/Components/mx_wifi
  asm include: ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F;../../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../Config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x20000
  memory RVCT7: RAM 0x38000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  scatter file: ClockAndWeather-STM32H735G-DK\Exe\ClockAndWeather.sct
  group Application/MDK-ARM
    ./: startup_stm32h735xx.s
  group Application/User/Core
    ../Core/Src/: bsp.c clock_weather_app.c ini.c main.cpp stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage.c
    ../JSON/: json_parsers.cpp
    ../../../../../../Middlewares/ST/STM32_Network_Library/templates/: net_conf_mxchip_uart.c
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Saira_Medium_22_4bpp_0.cpp Font_Saira_Medium_22_4bpp_4.cpp Font_Saira_Medium_28_4bpp_0.cpp Font_Saira_Medium_28_4bpp_4.cpp Font_Saira_Regular_18_4bpp_0.cpp Font_Saira_Regular_18_4bpp_4.cpp Font_Saira_Regular_34_4bpp_0.cpp Font_Saira_Regular_34_4bpp_4.cpp Font_SairaCondensed_SemiBold_12_4bpp_0.cpp Font_SairaCondensed_SemiBold_22_4bpp_0.cpp Font_SairaCondensed_SemiBold_32_4bpp_0.cpp Font_SairaCondensed_SemiBold_64_4bpp_0.cpp Font_SairaSemiCondensed_Medium_12_4bpp_0.cpp Font_SairaSemiCondensed_Medium_12_4bpp_4.cpp Font_SairaSemiCondensed_Medium_14_4bpp_0.cpp Font_SairaSemiCondensed_Medium_14_4bpp_4.cpp Font_SairaSemiCondensed_Medium_16_4bpp_0.cpp Font_SairaSemiCondensed_Medium_16_4bpp_4.cpp Font_SairaSemiCondensed_Medium_18_4bpp_0.cpp Font_SairaSemiCondensed_Medium_18_4bpp_4.cpp Font_SairaSemiCondensed_Medium_20_4bpp_0.cpp Font_SairaSemiCondensed_Medium_20_4bpp_4.cpp FontCache.cpp GeneratedFont.cpp Kerning_Saira_Medium_22_4bpp.cpp Kerning_Saira_Medium_28_4bpp.cpp Kerning_Saira_Regular_18_4bpp.cpp Kerning_Saira_Regular_34_4bpp.cpp Kerning_SairaCondensed_SemiBold_12_4bpp.cpp Kerning_SairaCondensed_SemiBold_22_4bpp.cpp Kerning_SairaCondensed_SemiBold_32_4bpp.cpp Kerning_SairaCondensed_SemiBold_64_4bpp.cpp Kerning_SairaSemiCondensed_Medium_12_4bpp.cpp Kerning_SairaSemiCondensed_Medium_14_4bpp.cpp Kerning_SairaSemiCondensed_Medium_16_4bpp.cpp Kerning_SairaSemiCondensed_Medium_18_4bpp.cpp Kerning_SairaSemiCondensed_Medium_20_4bpp.cpp Table_Saira_Medium_22_4bpp.cpp Table_Saira_Medium_28_4bpp.cpp Table_Saira_Regular_18_4bpp.cpp Table_Saira_Regular_34_4bpp.cpp Table_SairaCondensed_SemiBold_12_4bpp.cpp Table_SairaCondensed_SemiBold_22_4bpp.cpp Table_SairaCondensed_SemiBold_32_4bpp.cpp Table_SairaCondensed_SemiBold_64_4bpp.cpp Table_SairaSemiCondensed_Medium_12_4bpp.cpp Table_SairaSemiCondensed_Medium_14_4bpp.cpp Table_SairaSemiCondensed_Medium_16_4bpp.cpp Table_SairaSemiCondensed_Medium_18_4bpp.cpp Table_SairaSemiCondensed_Medium_20_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/cloudandweather_screen
    ../TouchGFX/generated/gui_generated/src/cloudandweather_screen/: CloudAndWeatherViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: currentWeatherDataContainerBase.cpp forecastBarContainerBase.cpp forecastContainerBase.cpp forecastWheelContainerBase.cpp settingsContainerBase.cpp wifiConnectingContainerBase.cpp wifiInfoLargeContainerBase.cpp wifiInfoSmallContainerBase.cpp wifiMenuContainerBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp
  group Application/User/TouchGFX/generated/images/Extra_icons
    ../TouchGFX/generated/images/src/Extra_icons/: pressure.cpp Rain_volume.cpp wind.cpp
  group Application/User/TouchGFX/generated/images/Gradient_bg
    ../TouchGFX/generated/images/src/Gradient_bg/: afternoon.cpp midday.cpp night.cpp sunrise.cpp
  group Application/User/TouchGFX/generated/images/other_icons
    ../TouchGFX/generated/images/src/other_icons/: close.cpp settings.cpp wifi_dot_icon_24-2x.cpp wifi_dot_icon_24-3x.cpp wifi_dot_icon_24.cpp wifi_full_icon_24-2x.cpp wifi_full_icon_24-3x.cpp wifi_full_icon_24.cpp wifi_low_icon_24-2x.cpp wifi_low_icon_24-3x.cpp wifi_low_icon_24.cpp wifi_mid_icon_24-2x.cpp wifi_mid_icon_24-3x.cpp wifi_mid_icon_24.cpp
  group Application/User/TouchGFX/generated/images/settings
    ../TouchGFX/generated/images/src/settings/: error_box.cpp errorButton.cpp keyboard_normal.cpp keyboard_pressed_backspace.cpp keyboard_pressed_capslock.cpp keyboard_pressed_done.cpp keyboard_pressed_key.cpp keyboard_pressed_mode.cpp keyboard_pressed_space.cpp list_selection.cpp settings_box_bg.cpp settings_slider_12.cpp settings_slider_24.cpp settings_slider_C.cpp settings_slider_F.cpp wifi_lock.cpp
  group Application/User/TouchGFX/generated/images/weatherIcons
    ../TouchGFX/generated/images/src/weatherIcons/: broken_clouds_icon_24.cpp broken_clouds_icon_64.cpp broken_clouds_night_icon_24.cpp broken_clouds_night_icon_64.cpp clear_sky_icon_24.cpp clear_sky_icon_64.cpp clear_sky_night_icon_24.cpp clear_sky_night_icon_64.cpp few_clouds_icon_24.cpp few_clouds_icon_64.cpp few_clouds_night_icon_24.cpp few_clouds_night_icon_64.cpp mist_icon_24.cpp mist_icon_64.cpp mist_night_icon_24.cpp mist_night_icon_64.cpp rain_icon_24.cpp rain_icon_64.cpp rain_night_icon_24.cpp rain_night_icon_64.cpp scattered_clouds_icon_24.cpp scattered_clouds_icon_64.cpp scattered_clouds_night_icon_24.cpp scattered_clouds_night_icon_64.cpp snow_icon_24.cpp snow_icon_64.cpp snow_night_icon_24.cpp snow_night_icon_64.cpp thunder_icon_24.cpp thunder_icon_64.cpp thunder_night_icon_24.cpp thunder_night_icon_64.cpp
  group Application/User/TouchGFX/generated/images/Wifi
    ../TouchGFX/generated/images/src/Wifi/: no_wifi.cpp wifi_1.cpp wifi_2.cpp wifi_3.cpp wifi_dot.cpp wifi_dot_settings.cpp wifi_error.cpp wifi_full.cpp wifi_full_settings.cpp wifi_level_1.cpp wifi_level_2.cpp wifi_level_3.cpp wifi_level_4.cpp wifi_low.cpp wifi_low_settings.cpp wifi_mid.cpp wifi_mid_settings.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/cloudandweather_screen
    ../TouchGFX/gui/src/cloudandweather_screen/: CloudAndWeatherPresenter.cpp CloudAndWeatherView.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: ClockAndDate.cpp CustomKeyboard.cpp FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: currentWeatherDataContainer.cpp forecastBarContainer.cpp forecastContainer.cpp forecastWheelContainer.cpp settingsContainer.cpp wifiConnectingContainer.cpp wifiInfoLargeContainer.cpp wifiInfoSmallContainer.cpp wifiMenuContainer.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Drivers/BSP/Components/MXCHIP
    ../../../../../../Drivers/BSP/Components/mx_wifi/: CheckSumUtils.c mx_wifi.c mx_wifi_hci.c mx_wifi_ipc.c mx_wifi_slip.c
    ../../../../../../Drivers/BSP/Components/mx_wifi/lib_ipc/: ipc_recv.c ipc_send.c
  group Drivers/BSP/Components/FT5336
    ../../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/BSP/Components/GT911
    ../../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
  group Drivers/BSP/Components/S70KL1281
    ../../../../../../Drivers/BSP/Components/s70kl1281/: s70kl1281.c
  group Drivers/BSP/Components/MX25LM51245G
    ../../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/STM32H735G-DK
    ../../../../../../Drivers/BSP/STM32H735G-DK/: stm32h735g_discovery.c stm32h735g_discovery_bus.c stm32h735g_discovery_ospi.c stm32h735g_discovery_sd.c stm32h735g_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c
  group Middleware/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middleware/FatFs/Drivers
    ../Core/Src/: sd_diskio.c
  group Middleware/FatFs/Options
    ../../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middleware/FreeRTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/FreeRTOS/CMSIS_RTOS
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware/FreeRTOS/MemMgr
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middleware/FreeRTOS/Portable
    ../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middleware/STM32_Network_Library/core
    ../../../../../../Middlewares/ST/STM32_Network_Library/core/: net_address.c net_class_extension.c net_core.c net_os.c net_socket.c net_state.c
  group Middleware/STM32_Network_Library/netif
    ../../../../../../Middlewares/ST/STM32_Network_Library/netif/wifi_if/mx_wifi/: net_mx_wifi.c
  group Middleware/TouchGFX/Lib
    ../../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core_release.a
    ../../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middleware/TouchGFX/OS
    ../../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers_cmsis.cpp
  group Middleware/TouchGFX/Target
    ../TouchGFX/target/: BoardConfiguration.cpp Buttons.cpp GPIO.cpp KeySampler.cpp STM32H7DMA.cpp STM32H7HAL.cpp STM32H7Instrumentation.cpp STM32H7TouchController.cpp
  group Middleware/TouchGFX/Widgets
    ../TouchGFX/widgets/: SwipeContainerWithCallback.cpp
software components: CMSIS:CORE 5.2.0
