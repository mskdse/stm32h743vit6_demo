# Keil uVision project MenuLauncher.uvprojx, settings and files
target MenuLauncher-STM32H735G-DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H735IGKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.2
  cpu: IROM_ML(0x08000000-0x807FFFF) IRAM2(0x00000000-0x3FFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x24000000-0x2404FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: MenuLauncher +hex
  c flags: Optim=4 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: ST,STM32H735xx,USE_STM32H735G_DK,BSP_USE_CMSIS_OS,USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,USE_BPP=24
  c include: ../Config;../Gui/gui/include;../Gui/generated/fonts/include;../Gui/generated/images/include;../Gui/generated/texts/include;../Gui/generated/gui_generated/include;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32H735G-DK;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Gui/target;../Core/Inc;../../../../../Drivers/CMSIS/Include
  asm include: ../Config
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x70000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: MenuLauncher.sct
  group Application/MDK-ARM
    ./: startup_stm32h735xx.s
  group Application/User/Core
    ../Core/Src/: bsp.c main.cpp stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/TouchGFX/generated/fonts
    ../Gui/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Saira_Bold_24_4bpp_0.cpp Font_Saira_Medium_18_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_Saira_Bold_24_4bpp.cpp Kerning_Saira_Medium_18_4bpp.cpp Table_Saira_Bold_24_4bpp.cpp Table_Saira_Medium_18_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../Gui/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../Gui/generated/gui_generated/src/containers/: iconContainerBase.cpp shadowContainerBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/main_screen
    ../Gui/generated/gui_generated/src/main_screen/: MainViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../Gui/generated/images/src/: bg.cpp BitmapDatabase.cpp design.cpp gradient.cpp icon_center_01.cpp icon_center_02.cpp icon_center_03.cpp launch_button.cpp shadow.cpp Shadow_small.cpp small_icon_center_01.cpp small_icon_center_02.cpp small_icon_center_03.cpp tab.cpp tab_reverse.cpp
  group Application/User/TouchGFX/generated/texts
    ../Gui/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../Gui/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../Gui/gui/src/containers/: iconContainer.cpp shadowContainer.cpp
  group Application/User/TouchGFX/gui/main_screen
    ../Gui/gui/src/main_screen/: MainPresenter.cpp MainView.cpp
  group Application/User/TouchGFX/gui/model
    ../Gui/gui/src/model/: Model.cpp
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../../../Drivers/BSP/STM32H735G-DK/: stm32h735g_discovery.c stm32h735g_discovery_bus.c stm32h735g_discovery_ospi.c stm32h735g_discovery_ts.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
    ../../../../../Drivers/BSP/Components/s70kl1281/: s70kl1281.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middlewares/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers.cpp
  group Middlewares/TouchGFX/Target
    ../Gui/target/: BoardConfiguration.cpp Buttons.cpp GPIO.cpp KeySampler.cpp STM32H7DMA.cpp STM32H7HAL.cpp STM32H7Instrumentation.cpp STM32H7TouchController.cpp
software components: CMSIS:CORE 4.3.0
