# Keil uVision project Project.uvprojx, settings and files
target STM32H7B3I_DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.7
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H7B3I_DISCO
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_DISCO
  c include: ../Inc;../../../../../../Drivers/BSP/STM32H7B3I-DK;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components;../../../../../../Utilities/Log;../../../../../../Utilities/Fonts;../../../../../../Utilities/CPU;../../../../../../Utilities/LCD;../../../../../../Middlewares/ST/STemWin/inc;../Core/Inc;../STemWin/Target
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c
  group Application/User/STemWin
    ../STemWin/App/: BASIC_HelloWorld.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/IS42S16800J
    ../../../../../../Drivers/BSP/Components/is42s16800j/: is42s16800j.c
  group Drivers/BSP/STM32H7B3I-DK
    ../../../../../../Drivers/BSP/STM32H7B3I-DK/: stm32h7b3i_discovery_sdram.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_fmc.c
  group Middlewares/Lib
    ../../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_wc16_ARGB.a
  group Middlewares/OS
    ../../../../../../Middlewares/ST/STemWin/OS/: GUI_X.c
  group Middlewares/Target
    ../STemWin/Target/: GUIConf_stm32h7b3i_discovery.c LCDConf_stm32h7b3i_discovery.c
software components: CMSIS:CORE 4.3.0
