# Keil uVision project MenuLauncher.uvprojx, settings and files
target MenuLauncher-STM32H7B3I-DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.4
  cpu: IROM(0x08000000-0x801FFFF) IRAM2(0x00000000-0xFFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x24000000-0x240FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: MenuLauncher +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_DK,USE_BPP=24,ST,USE_FLOATING_POINT
  c misc: --diag_suppress 1300
  c include: ../TouchGFX/generated/images/include;../TouchGFX/generated/fonts/include;../TouchGFX/generated/texts/include;../TouchGFX/generated/gui_generated/include;../TouchGFX/gui/include;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STM32H7B3I-DK;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../Config;../Core/Inc;../../../../../Drivers/CMSIS/Include;..;../TouchGFX/target
  asm include: ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: MenuLauncher-STM32H7B3I-DK\Exe\MenuLauncher.sct
  link misc: --diag_suppress=L6329
  group Application/Doc
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Application/User/Core
    ../Core/Src/: bsp.c main.cpp stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Saira_Medium_14_4bpp_0.cpp Font_Saira_Medium_14_4bpp_4.cpp Font_Saira_Medium_28_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_Saira_Medium_14_4bpp.cpp Kerning_Saira_Medium_28_4bpp.cpp Table_Saira_Medium_14_4bpp.cpp Table_Saira_Medium_28_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: infoBoxBase.cpp optionButtonSelectedBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/mainscreen_screen
    ../TouchGFX/generated/gui_generated/src/mainscreen_screen/: mainScreenViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: back_button.cpp BitmapDatabase.cpp pop_overlay.cpp start_button.cpp testcreativity.cpp
  group Application/User/TouchGFX/generated/images/boxes
    ../TouchGFX/generated/images/src/boxes/: box_01.cpp box_02.cpp box_03.cpp box_04.cpp box_05.cpp box_06.cpp box_07.cpp small_box_01.cpp small_box_02.cpp small_box_03.cpp small_box_04.cpp small_box_05.cpp small_box_06.cpp small_box_07.cpp
  group Application/User/TouchGFX/generated/images/icons
    ../TouchGFX/generated/images/src/icons/: icon_01.cpp icon_02.cpp icon_03.cpp icon_04.cpp icon_05.cpp icon_06.cpp icon_07.cpp small_icon_01.cpp small_icon_02.cpp small_icon_03.cpp small_icon_04.cpp small_icon_05.cpp small_icon_06.cpp small_icon_07.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: infoBox.cpp optionButtonSelected.cpp
  group Application/User/TouchGFX/gui/mainscreen_screen
    ../TouchGFX/gui/src/mainscreen_screen/: mainScreenPresenter.cpp mainScreenView.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Drivers/BSP/Components/FT5336
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/BSP/Components/IS42S16800J
    ../../../../../Drivers/BSP/Components/is42s16800j/: is42s16800j.c
  group Drivers/BSP/Components/MX25LM51245G
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/STM32H7B3I-DK
    ../../../../../Drivers/BSP/STM32H7B3I-DK/: stm32h7b3i_discovery.c stm32h7b3i_discovery_bus.c stm32h7b3i_discovery_ospi.c stm32h7b3i_discovery_sdram.c stm32h7b3i_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_usb.c
  group Middleware/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middleware/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middleware/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middleware/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers_cmsis.cpp
  group Middleware/TouchGFX/Target
    ../TouchGFX/target/: BoardConfiguration.cpp Buttons.cpp GPIO.cpp KeySampler.cpp STM32H7DMA.cpp STM32H7HAL.cpp STM32H7Instrumentation.cpp STM32H7TouchController.cpp
