# Keil uVision project VideoPlayer.uvprojx, settings and files
target VideoPlayer-STM32H7B3I-DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.9
  cpu: IROM(0x08140000-0x819FFFF) IRAM2(0x00000000-0xFFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x24000000-0x240FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: VideoPlayer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_DK,USE_BPP=24,USE_FLOATING_POINT,USE_SDCARD,__EDG_IMPLICIT_USING_STD
  c misc: --diag_suppress 1300
  c include: ../TouchGFX/generated/images/include;../TouchGFX/generated/fonts/include;../TouchGFX/generated/texts/include;../TouchGFX/generated/gui_generated/include;../TouchGFX/gui/include;../TouchGFX/widgets/Config;../TouchGFX/widgets/include;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STM32H7B3I-DK;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../../../../../Middlewares/Third_Party/LibJPEG/include;../../../../../Utilities/JPEG;../Config;../Core/Inc;../../../../../Drivers/CMSIS/Include;..;../TouchGFX/target
  asm include: ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../Config
  memory RVCT4: ROM 0x8140000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\VideoPlayer-STM32H7B3I-DK_V1.0.sct
  link misc: --no_remove
  group Application/MDK-ARM
    ./: startup_stm32h7b3xxq.s
    ./: Media.s
  group Application/User/Core
    ../Core/Src/: avi_parser.c avi_player.c bsp.c hwjpeg_decode.c main.cpp riff.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage.c
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_SairaCondensed_Bold_14_4bpp_0.cpp Font_SairaCondensed_Medium_12_4bpp_0.cpp Font_SairaCondensed_Medium_14_4bpp_0.cpp Font_SairaCondensed_Medium_14_4bpp_4.cpp Font_SairaCondensed_Medium_18_4bpp_0.cpp Font_SairaCondensed_Medium_28_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_SairaCondensed_Bold_14_4bpp.cpp Kerning_SairaCondensed_Medium_12_4bpp.cpp Kerning_SairaCondensed_Medium_14_4bpp.cpp Kerning_SairaCondensed_Medium_18_4bpp.cpp Kerning_SairaCondensed_Medium_28_4bpp.cpp Table_SairaCondensed_Bold_14_4bpp.cpp Table_SairaCondensed_Medium_12_4bpp.cpp Table_SairaCondensed_Medium_14_4bpp.cpp Table_SairaCondensed_Medium_18_4bpp.cpp Table_SairaCondensed_Medium_28_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: thumbnailContainerBase.cpp trackBase.cpp trackSelectorBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/videoplayer_screen
    ../TouchGFX/generated/gui_generated/src/videoplayer_screen/: VideoPlayerViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp bottom_bar.cpp led_on.cpp LP_800x480_animation0000.cpp
  group Application/User/TouchGFX/generated/images/buttons
    ../TouchGFX/generated/images/src/buttons/: button_album.cpp button_album_pressed.cpp button_back.cpp button_back_pressed.cpp button_next_track_overlay.cpp button_next_track_pressed.cpp button_prev_track_overlay.cpp button_prev_track_pressed.cpp icon_low_power.cpp icon_low_power_pressed.cpp icon_pause.cpp icon_play.cpp
  group Application/User/TouchGFX/generated/images/slider
    ../TouchGFX/generated/images/src/slider/: audio_slider_bar.cpp audio_slider_fill_paused.cpp audio_slider_fill_playing.cpp audio_slider_knob.cpp volume_bar.cpp volume_bar_empty_bg.cpp volume_bar_fill.cpp volume_handle.cpp
  group Application/User/TouchGFX/generated/images/tracks
    ../TouchGFX/generated/images/src/tracks/: button_close_album.cpp button_close_album_pressed.cpp icon_list_pause.cpp icon_list_play.cpp icon_repeat_off.cpp icon_repeat_on.cpp icon_shuffle_off.cpp icon_shuffle_on.cpp shadow_list_bottom.cpp shadow_list_top.cpp track_list_box.cpp track_list_box_selected.cpp track_list_container.cpp
  group Application/User/TouchGFX/generated/images/videoSelector
    ../TouchGFX/generated/images/src/videoSelector/: content_indicator.cpp content_indicator_bar.cpp overlay_no_icon.cpp pause.cpp play.cpp shadow_left.cpp shadow_right.cpp title_underline.cpp video_clip_overlay.cpp video_clip_overlay_selected.cpp
  group Application/User/TouchGFX/generated/images/volume
    ../TouchGFX/generated/images/src/volume/: icon_volume_high.cpp icon_volume_high_pressed.cpp icon_volume_low.cpp icon_volume_low_pressed.cpp icon_volume_medium.cpp icon_volume_medium_pressed.cpp icon_volume_muted.cpp icon_volume_muted_pressed.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: thumbnailContainer.cpp track.cpp trackSelector.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/videoplayer_screen
    ../TouchGFX/gui/src/videoplayer_screen/: VideoPlayerPresenter.cpp VideoPlayerView.cpp
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/CS42L51
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
  group Drivers/BSP/Components/FT5336
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/BSP/Components/IS42S16800J
    ../../../../../Drivers/BSP/Components/is42s16800j/: is42s16800j.c
  group Drivers/BSP/Components/MFXSTM32L152
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/Components/MX25LM51245G
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/STM32H7B3I_DISCO
    ../../../../../Drivers/BSP/STM32H7B3I-DK/: stm32h7b3i_discovery.c stm32h7b3i_discovery_audio.c stm32h7b3i_discovery_bus.c stm32h7b3i_discovery_ospi.c stm32h7b3i_discovery_sd.c stm32h7b3i_discovery_sdram.c stm32h7b3i_discovery_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Middleware/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middleware/FatFs/Drivers
    ../Core/Src/: sd_diskio.c
  group Middleware/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middleware/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middleware/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middleware/libJPEG
    ../../../../../Middlewares/Third_Party/LibJPEG/source/: jaricom.c jcapimin.c jcapistd.c jcarith.c jccoefct.c jccolor.c jcdctmgr.c jchuff.c jcinit.c jcmainct.c jcmarker.c jcmaster.c jcomapi.c jcparam.c jcprepct.c jcsample.c jctrans.c jdapimin.c jdapistd.c jdarith.c jdatasrc.c jdcoefct.c jdcolor.c jddctmgr.c jdhuff.c jdinput.c jdmainct.c jdmarker.c jdmaster.c jdmerge.c jdpostct.c jdsample.c jdtrans.c jerror.c jfdctflt.c jfdctfst.c jfdctint.c jidctflt.c jidctfst.c jidctint.c jmemmgr.c jmemnobs.c jquant1.c jquant2.c jutils.c
  group Middleware/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middleware/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers_cmsis.cpp
  group Middleware/TouchGFX/Target
    ../TouchGFX/target/: BoardConfiguration.cpp Buttons.cpp GPIO.cpp KeySampler.cpp STM32H7DMA.cpp STM32H7HAL.cpp STM32H7Instrumentation.cpp STM32H7TouchController.cpp
  group Middleware/TouchGFX/Widgets
    ../TouchGFX/widgets/src/: FatFSFileInput.cpp JPEGFile.cpp MJPEGReader.cpp MJPEGWidget.cpp
  group Utilities/JPEG
    ../../../../../Utilities/JPEG/: jpeg_utils.c
target VideoPlayer-STM32H7B3I-DK_OoB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7A-B3_DFP.2.1.9
  cpu: as above
  output: VideoPlayer +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_DK,USE_BPP=24,USE_FLOATING_POINT,USE_STM32H7B3I_DK_OOB,USE_SDCARD,__EDG_IMPLICIT_USING_STD
  c misc: --diag_suppress 1300
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x8140000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\VideoPlayer-STM32H7B3I-DK_OoB_V1.0.sct
  link misc: --no_remove
software components: CMSIS:CORE 4.3.0
