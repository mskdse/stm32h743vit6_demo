# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (6120000::V6.12::.\ARMCLANG)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743I_EVAL
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_PWR_LDO_SUPPLY, STM32H743xx
  c include: ../Inc;../../../../Drivers/CMSIS/Include;../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../Drivers/STM32H7xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Doc
    ../: readme.txt
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_LL_Driver
    ../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_crc.c stm32h7xx_ll_dac.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32h743xx.s
  group Example/User
    ../Src/: main.c stm32h7xx_it.c
software components: CMSIS:CORE 5.2.0
