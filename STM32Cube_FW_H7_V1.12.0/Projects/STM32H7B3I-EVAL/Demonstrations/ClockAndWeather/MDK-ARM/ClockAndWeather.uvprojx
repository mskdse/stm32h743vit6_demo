# Keil uVision project ClockAndWeather.uvprojx, settings and files
target ClockAndWeather-STM32H7B3I-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: ClockAndWeather +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_EVAL,USE_BPP=24,ST,USE_FLOATING_POINT,USE_SDCARD
  c misc: --diag_suppress 1300
  c include: ../TouchGFX/generated/images/include;../TouchGFX/generated/fonts/include;../TouchGFX/generated/texts/include;../TouchGFX/generated/gui_generated/include;../TouchGFX/gui/include;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STM32H7B3I-EVAL;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../Config;../Core/Inc;../../../../../Drivers/CMSIS/Include;..;../TouchGFX/target;../TouchGFX/widgets;../JSON;../../../../../Middlewares/ST/STM32_Network_Library/Includes;../../../../../Drivers/BSP/Components/es_wifi
  asm include: ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../Config
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ClockAndWeather-STM32H7B3I-EVAL\Exe\ClockAndWeather-STM32H7B.sct
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Application/User/Core
    ../Core/Src/: clock_weather_app.c ini.c main.cpp net_conf_es_wifi_spi.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage.c
    ../JSON/: json_parsers.cpp
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Saira_Medium_22_4bpp_0.cpp Font_Saira_Medium_28_4bpp_0.cpp Font_SairaCondensed_SemiBold_100_4bpp_0.cpp Font_SairaCondensed_SemiBold_12_4bpp_0.cpp Font_SairaCondensed_SemiBold_30_4bpp_0.cpp Font_SairaCondensed_SemiBold_42_4bpp_0.cpp Font_SairaSemiCondensed_Medium_16_4bpp_0.cpp Font_SairaSemiCondensed_Medium_20_4bpp_0.cpp Font_SairaSemiCondensed_Medium_20_4bpp_4.cpp Font_SairaSemiCondensed_Medium_24_4bpp_0.cpp Font_SairaSemiCondensed_Medium_24_4bpp_4.cpp Font_SairaSemiCondensed_Medium_34_4bpp_0.cpp Font_SairaSemiCondensed_Medium_34_4bpp_4.cpp Font_SairaSemiCondensed_Medium_56_4bpp_0.cpp Font_SairaSemiCondensed_Medium_56_4bpp_4.cpp FontCache.cpp GeneratedFont.cpp Kerning_Saira_Medium_22_4bpp.cpp Kerning_Saira_Medium_28_4bpp.cpp Kerning_SairaCondensed_SemiBold_100_4bpp.cpp Kerning_SairaCondensed_SemiBold_12_4bpp.cpp Kerning_SairaCondensed_SemiBold_30_4bpp.cpp Kerning_SairaCondensed_SemiBold_42_4bpp.cpp Kerning_SairaSemiCondensed_Medium_16_4bpp.cpp Kerning_SairaSemiCondensed_Medium_20_4bpp.cpp Kerning_SairaSemiCondensed_Medium_24_4bpp.cpp Kerning_SairaSemiCondensed_Medium_34_4bpp.cpp Kerning_SairaSemiCondensed_Medium_56_4bpp.cpp Table_Saira_Medium_22_4bpp.cpp Table_Saira_Medium_28_4bpp.cpp Table_SairaCondensed_SemiBold_100_4bpp.cpp Table_SairaCondensed_SemiBold_12_4bpp.cpp Table_SairaCondensed_SemiBold_30_4bpp.cpp Table_SairaCondensed_SemiBold_42_4bpp.cpp Table_SairaSemiCondensed_Medium_16_4bpp.cpp Table_SairaSemiCondensed_Medium_20_4bpp.cpp Table_SairaSemiCondensed_Medium_24_4bpp.cpp Table_SairaSemiCondensed_Medium_34_4bpp.cpp Table_SairaSemiCondensed_Medium_56_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/cloudandweather_screen
    ../TouchGFX/generated/gui_generated/src/cloudandweather_screen/: CloudAndWeatherViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: currentWeatherDataContainerBase.cpp forecastBarContainerBase.cpp forecastContainerBase.cpp forecastWheelContainerBase.cpp settingsContainerBase.cpp wifiConnectingContainerBase.cpp wifiInfoLargeContainerBase.cpp wifiInfoSmallContainerBase.cpp wifiMenuContainerBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: BitmapDatabase.cpp close.cpp error_box.cpp path2.cpp settings.cpp settings_12_button.cpp settings_24_button.cpp settings_box_bg.cpp settings_celcius_button.cpp settings_fahrenheit_button.cpp settings_slider_bg.cpp settings_slider_button.cpp trye_again_button.cpp UI_settings.cpp UI_wifi_error.cpp
  group Application/User/TouchGFX/generated/images/Extra_icons
    ../TouchGFX/generated/images/src/Extra_icons/: pressure.cpp Rain_volume.cpp wind.cpp
  group Application/User/TouchGFX/generated/images/Final_weather_icons
    ../TouchGFX/generated/images/src/Final_weather_icons/: icon_48_Broken_clouds.cpp icon_48_Broken_clouds_night.cpp icon_48_Clear_sky.cpp icon_48_Clear_sky_night.cpp icon_48_Few_clouds.cpp icon_48_Few_clouds_night.cpp icon_48_Mist.cpp icon_48_Mist_night.cpp icon_48_Rain.cpp icon_48_Rain_night.cpp icon_48_Scattered_clouds.cpp icon_48_Scattered_clouds_night.cpp icon_48_Snow.cpp icon_48_Snow_night.cpp icon_48_Thunder.cpp icon_48_Thunder_night.cpp
  group Application/User/TouchGFX/generated/images/Final_weather_icons_big
    ../TouchGFX/generated/images/src/Final_weather_icons_big/: icon_144_Broken_clouds.cpp icon_144_Broken_clouds_night.cpp icon_144_Clear_sky.cpp icon_144_Clear_sky_night.cpp icon_144_Few_clouds.cpp icon_144_Few_clouds_night.cpp icon_144_Mist.cpp icon_144_Mist_night.cpp icon_144_Rain.cpp icon_144_Rain_night.cpp icon_144_Scattered_clouds.cpp icon_144_Scattered_clouds_night.cpp icon_144_Snow.cpp icon_144_Snow_night.cpp icon_144_Thunder.cpp icon_144_Thunder_night.cpp
  group Application/User/TouchGFX/generated/images/Gradient_bg
    ../TouchGFX/generated/images/src/Gradient_bg/: afternoon.cpp midday.cpp night.cpp sunrise.cpp
  group Application/User/TouchGFX/generated/images/Keyboard
    ../TouchGFX/generated/images/src/Keyboard/: keyboard_normal.cpp keyboard_pressed.cpp keyboard_pressed_backspace.cpp keyboard_pressed_capslock.cpp keyboard_pressed_done.cpp keyboard_pressed_key.cpp keyboard_pressed_mode.cpp keyboard_pressed_space.cpp
  group Application/User/TouchGFX/generated/images/Wifi
    ../TouchGFX/generated/images/src/Wifi/: no_wifi.cpp wifi_1.cpp wifi_2.cpp wifi_3.cpp wifi_dot.cpp wifi_dot_icon_2x.cpp wifi_dot_settings.cpp wifi_error.cpp wifi_full.cpp wifi_full_icon_2x.cpp wifi_full_settings.cpp wifi_level_1.cpp wifi_level_2.cpp wifi_level_3.cpp wifi_level_4.cpp wifi_lock.cpp wifi_low.cpp wifi_low_icon_2x.cpp wifi_mid.cpp wifi_mid_icon_2x.cpp wifi_mid_settings.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/cloudandweather_screen
    ../TouchGFX/gui/src/cloudandweather_screen/: CloudAndWeatherPresenter.cpp CloudAndWeatherView.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: ClockAndDate.cpp CustomKeyboard.cpp FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: currentWeatherDataContainer.cpp forecastBarContainer.cpp forecastContainer.cpp forecastWheelContainer.cpp settingsContainer.cpp wifiConnectingContainer.cpp wifiInfoLargeContainer.cpp wifiInfoSmallContainer.cpp wifiMenuContainer.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/CS42L51
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
  group Drivers/BSP/Components/ES_WIFI
    ../../../../../Drivers/BSP/Components/es_wifi/: es_wifi.c
  group Drivers/BSP/Components/FT5336
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/BSP/Components/GT911
    ../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
  group Drivers/BSP/Components/IS42S32800J
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
  group Drivers/BSP/Components/MFXSTM32L152
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/Components/MX25LM51245G
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/STM32H7B3I_EVAL
    ../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_io.c stm32h7b3i_eval_ospi.c stm32h7b3i_eval_sd.c stm32h7b3i_eval_sdram.c stm32h7b3i_eval_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c
  group Middleware/FatsFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middleware/FatsFs/Drivers
    ../Core/Src/: sd_diskio.c
  group Middleware/FatsFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middleware/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middleware/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middleware/STM32_Network_Library/core
    ../../../../../Middlewares/ST/STM32_Network_Library/core/: net_address.c net_class_extension.c net_core.c net_os.c net_socket.c net_state.c
  group Middleware/STM32_Network_Library/netif
    ../../../../../Middlewares/ST/STM32_Network_Library/netif/wifi_if/es_wifi/: net_es_wifi.c
  group Middleware/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middleware/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers_cmsis.cpp
  group Middleware/TouchGFX/Target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp STM32H7DMA.cpp STM32H7HAL.cpp STM32H7Instrumentation.cpp STM32H7TouchController.cpp
  group Middleware/TouchGFX/Widgets
    ../TouchGFX/widgets/: SwipeContainerWithCallback.cpp
target ClockAndWeather-STM32H7B3I-EVAL_OoB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.1
  cpu: as above
  output: ClockAndWeather +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_EVAL,USE_BPP=24,ST,USE_FLOATING_POINT,USE_SDCARD,USE_STM32H7B3I_EVAL_OOB
  c misc: --diag_suppress 1300
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ClockAndWeather-STM32H7B3I-EVAL_OoB\Exe\ClockAndWeather.sct
