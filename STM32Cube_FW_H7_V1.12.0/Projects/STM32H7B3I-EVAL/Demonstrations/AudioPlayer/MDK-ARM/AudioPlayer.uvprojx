# Keil uVision project AudioPlayer.uvprojx, settings and files
target AudioPlayer-STM32H7B3I-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: IROM(0x08100000-0x813FFFF) IRAM2(0x00000000-0xFFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x24000000-0x240FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: AudioPlayer-STM32H7B3I-EVAL_V1.0.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_EVAL,USE_BPP=24,ST,USE_FLOATING_POINT,USE_SDCARD
  c misc: --diag_suppress 1300
  c include: ../TouchGFX/generated/images/include;../TouchGFX/generated/fonts/include;../TouchGFX/generated/texts/include;../TouchGFX/generated/gui_generated/include;../TouchGFX/gui/include;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STM32H7B3I-EVAL;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers;../Config;../Core/Inc;../../../../../Drivers/CMSIS/Include;..;../TouchGFX/target;../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../Codecs/SpiritDSP_MP3_Dec/inc;../Addons/Common/Inc;../Addons/SRC236/Inc;../Addons/SRC441/Inc;../Codecs/SpiritDSP_MP3_Dec/inc
  asm include: ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../Config
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\AudioPlayer-STM32H7B3I-EVAL_V1.0.sct
  group Application/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Application/User/Core
    ../Core/Src/: audio_lowpower.c audio_player_app.c coders.c fwkmempool.c main.cpp mp3process.c player.c songutilities.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage.c wavprocess.c
  group Application/User/TouchGFX/generated/fonts
    ../TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_SairaCondensed_Bold_18_4bpp_0.cpp Font_SairaCondensed_Medium_18_4bpp_0.cpp Font_SairaCondensed_Medium_20_4bpp_0.cpp Font_SairaCondensed_Medium_20_4bpp_4.cpp Font_SairaCondensed_Medium_24_4bpp_0.cpp Font_SairaCondensed_Medium_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_SairaCondensed_Bold_18_4bpp.cpp Kerning_SairaCondensed_Medium_18_4bpp.cpp Kerning_SairaCondensed_Medium_20_4bpp.cpp Kerning_SairaCondensed_Medium_24_4bpp.cpp Kerning_SairaCondensed_Medium_40_4bpp.cpp Table_SairaCondensed_Bold_18_4bpp.cpp Table_SairaCondensed_Medium_18_4bpp.cpp Table_SairaCondensed_Medium_20_4bpp.cpp Table_SairaCondensed_Medium_24_4bpp.cpp Table_SairaCondensed_Medium_40_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/audio_player_screen
    ../TouchGFX/generated/gui_generated/src/audio_player_screen/: audio_playerViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../TouchGFX/generated/gui_generated/src/containers/: trackBase.cpp trackSelectorBase.cpp
  group Application/User/TouchGFX/generated/images
    ../TouchGFX/generated/images/src/: audio_background.cpp BitmapDatabase.cpp led_on.cpp
  group Application/User/TouchGFX/generated/images/animation
    ../TouchGFX/generated/images/src/animation/: LP_800x480_animation0000.cpp LP_800x480_animation0001.cpp LP_800x480_animation0002.cpp LP_800x480_animation0003.cpp LP_800x480_animation0004.cpp LP_800x480_animation0005.cpp LP_800x480_animation0006.cpp LP_800x480_animation0007.cpp LP_800x480_animation0008.cpp LP_800x480_animation0009.cpp LP_800x480_animation0010.cpp LP_800x480_animation0011.cpp LP_800x480_animation0012.cpp LP_800x480_animation0013.cpp LP_800x480_animation0014.cpp
  group Application/User/TouchGFX/generated/images/buttons
    ../TouchGFX/generated/images/src/buttons/: bottom_bar.cpp button_album.cpp button_album_pressed.cpp button_back.cpp button_back_pressed.cpp button_close_album.cpp button_close_album_pressed.cpp button_next_track_overlay.cpp button_next_track_pressed.cpp button_play_pressed.cpp button_prev_track_overlay.cpp button_prev_track_pressed.cpp icon_low_power.cpp icon_low_power_pressed.cpp icon_pause.cpp icon_play.cpp
  group Application/User/TouchGFX/generated/images/powersave
    ../TouchGFX/generated/images/src/powersave/: button_cancel.cpp button_cancel_pressed.cpp power_save_icon.cpp power_save_title_and_icon.cpp
  group Application/User/TouchGFX/generated/images/slider
    ../TouchGFX/generated/images/src/slider/: audio_slider_bar.cpp audio_slider_fill_paused.cpp audio_slider_fill_playing.cpp audio_slider_knob.cpp volume_bar.cpp volume_bar_empty_bg.cpp volume_bar_fill.cpp volume_handle.cpp
  group Application/User/TouchGFX/generated/images/tracks
    ../TouchGFX/generated/images/src/tracks/: content_indicator.cpp content_indicator_bar.cpp icon_list_pause.cpp icon_list_play.cpp icon_repeat_off.cpp icon_repeat_on.cpp icon_shuffle_off.cpp icon_shuffle_on.cpp shadow_list_bottom.cpp shadow_list_top.cpp shadow_list_topBOTTOM.cpp track_list_box.cpp track_list_box_selected.cpp track_list_container.cpp
  group Application/User/TouchGFX/generated/images/volume
    ../TouchGFX/generated/images/src/volume/: icon_volume_high.cpp icon_volume_high_pressed.cpp icon_volume_low.cpp icon_volume_low_pressed.cpp icon_volume_medium.cpp icon_volume_medium_pressed.cpp icon_volume_muted.cpp icon_volume_muted_pressed.cpp
  group Application/User/TouchGFX/generated/texts
    ../TouchGFX/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/audio_player_screen
    ../TouchGFX/gui/src/audio_player_screen/: audio_playerPresenter.cpp audio_playerView.cpp
  group Application/User/TouchGFX/gui/common
    ../TouchGFX/gui/src/common/: FrontendApplication.cpp
  group Application/User/TouchGFX/gui/containers
    ../TouchGFX/gui/src/containers/: track.cpp trackSelector.cpp
  group Application/User/TouchGFX/gui/model
    ../TouchGFX/gui/src/model/: Model.cpp
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/CS42L51
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
  group Drivers/BSP/Components/FT5336
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/BSP/Components/GT911
    ../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
  group Drivers/BSP/Components/IS42S32800J
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
  group Drivers/BSP/Components/MFXSTM32L152
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/Components/MX25LM51245G
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/STM32H7B3I_EVAL
    ../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_audio.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_io.c stm32h7b3i_eval_lcd.c stm32h7b3i_eval_ospi.c stm32h7b3i_eval_sd.c stm32h7b3i_eval_sdram.c stm32h7b3i_eval_ts.c
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_dfsdm.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group Middleware/AudioCodecs/MP3Decoder
    ../Codecs/SpiritDSP_MP3_Dec/lib/: lib_mp3decoder_cortex_m7_v2.2.0.a
  group Middleware/AudioCodecs/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM7_Keil_wc16.lib
  group Middleware/AudioCodecs/SRC
    ../Addons/SRC236/Lib/: SRC236_CM7_Keil.lib
    ../Addons/SRC441/Lib/: SRC441_CM7_Keil.lib
  group Middleware/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middleware/FatFs/Drivers
    ../Core/Src/: sd_diskio_dma.c
  group Middleware/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middleware/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middleware/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middleware/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middleware/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers_cmsis.cpp
  group Middleware/TouchGFX/Target
    ../TouchGFX/target/: BoardConfiguration.cpp GPIO.cpp STM32H7DMA.cpp STM32H7HAL.cpp STM32H7Instrumentation.cpp STM32H7TouchController.cpp
target AudioPlayer-STM327B3I-EVAL_OoB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.6
  cpu: as above
  output: AudioPlayer-STM32H7B3I-EVAL_OoB_V1.0.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_EVAL,USE_BPP=24,ST,USE_FLOATING_POINT,USE_SDCARD,USE_STM32H7B3I_EVAL_OOB
  c misc: --diag_suppress 1300
  c include: as above
  asm include: as above
  memory RVCT4: ROM 0x8100000 size 0x40000
  memory RVCT9: RAM 0x24000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\AudioPlayer-STM32H7B3I-EVAL_OoB_V1.0.sct
software components: CMSIS:CORE 4.3.0
