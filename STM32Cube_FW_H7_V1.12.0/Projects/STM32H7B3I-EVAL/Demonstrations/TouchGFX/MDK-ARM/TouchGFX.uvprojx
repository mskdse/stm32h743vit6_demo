# Keil uVision project TouchGFX.uvprojx, settings and files
target TouchGFX-STM32H7B3I-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.2
  cpu: IROM(0x08000000-0x801FFFF) IROM_TGFX(0x08020000-0x805FFFF) IRAM2(0x00000000-0xFFFF) IRAM(0x20000000-0x2001FFFF) IRAM(0x24000000-0x240FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: TouchGFX-STM32H7B3I-EVAL_V1.0.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_EVAL,USE_BPP=16,ST,USE_FLOATING_POINT
  c misc: --diag_suppress 1300
  c include: ../Config;../Core/Inc;../Gui/target;../Gui/gui/include;../Gui/generated/images/include;../Gui/generated/fonts/include;../Gui/generated/texts/include;../Gui/generated/gui_generated/include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/STM32H7B3I-EVAL;../../../../../Middlewares/ST/TouchGFX/touchgfx/framework/include;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include
  asm include: ../Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: TouchGFX-STM32H7B3I-EVAL\Exe\TouchGFX-STM32H7B3I-EVAL_V1.0.sct
  group Application/MDK-ARM
    ./: startup_stm32h7b3xxq.s
  group Application/User/Core
    ../Core/Src/: bsp.c main.cpp stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
  group Application/User/TouchGFX/generated/fonts
    ../Gui/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Asap_Bold_otf_20_4bpp_0.cpp Font_Asap_Bold_otf_27_4bpp_0.cpp Font_Asap_Regular_18_4bpp_0.cpp Font_Asap_Regular_20_4bpp_0.cpp Font_Asap_Regular_21_4bpp_0.cpp Font_Asap_Regular_28_4bpp_0.cpp Font_Asap_Regular_42_4bpp_0.cpp Font_Roboto_Bold_22_4bpp_0.cpp Font_Roboto_Medium_30_4bpp_0.cpp Font_RobotoCondensed_Bold_22_4bpp_0.cpp Font_RobotoCondensed_Bold_30_4bpp_0.cpp Font_RobotoCondensed_Bold_32_4bpp_0.cpp Font_RobotoCondensed_Bold_42_4bpp_0.cpp Font_RobotoCondensed_Bold_56_4bpp_0.cpp Font_RobotoCondensed_Bold_60_4bpp_0.cpp Font_RobotoCondensed_Bold_90_4bpp_0.cpp Font_RobotoCondensed_Regular_110_4bpp_0.cpp Font_RobotoCondensed_Regular_22_4bpp_0.cpp Font_RobotoCondensed_Regular_38_4bpp_0.cpp Font_RobotoCondensed_Regular_54_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_Asap_Bold_otf_20_4bpp.cpp Kerning_Asap_Bold_otf_27_4bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Kerning_Asap_Regular_20_4bpp.cpp Kerning_Asap_Regular_21_4bpp.cpp Kerning_Asap_Regular_28_4bpp.cpp Kerning_Asap_Regular_42_4bpp.cpp Kerning_Roboto_Bold_22_4bpp.cpp Kerning_Roboto_Medium_30_4bpp.cpp Kerning_RobotoCondensed_Bold_22_4bpp.cpp Kerning_RobotoCondensed_Bold_30_4bpp.cpp Kerning_RobotoCondensed_Bold_32_4bpp.cpp Kerning_RobotoCondensed_Bold_42_4bpp.cpp Kerning_RobotoCondensed_Bold_56_4bpp.cpp Kerning_RobotoCondensed_Bold_60_4bpp.cpp Kerning_RobotoCondensed_Bold_90_4bpp.cpp Kerning_RobotoCondensed_Regular_110_4bpp.cpp Kerning_RobotoCondensed_Regular_22_4bpp.cpp Kerning_RobotoCondensed_Regular_38_4bpp.cpp Kerning_RobotoCondensed_Regular_54_4bpp.cpp Table_Asap_Bold_otf_20_4bpp.cpp Table_Asap_Bold_otf_27_4bpp.cpp Table_Asap_Regular_18_4bpp.cpp Table_Asap_Regular_20_4bpp.cpp Table_Asap_Regular_21_4bpp.cpp Table_Asap_Regular_28_4bpp.cpp Table_Asap_Regular_42_4bpp.cpp Table_Roboto_Bold_22_4bpp.cpp Table_Roboto_Medium_30_4bpp.cpp Table_RobotoCondensed_Bold_22_4bpp.cpp Table_RobotoCondensed_Bold_30_4bpp.cpp Table_RobotoCondensed_Bold_32_4bpp.cpp Table_RobotoCondensed_Bold_42_4bpp.cpp Table_RobotoCondensed_Bold_56_4bpp.cpp Table_RobotoCondensed_Bold_60_4bpp.cpp Table_RobotoCondensed_Bold_90_4bpp.cpp Table_RobotoCondensed_Regular_110_4bpp.cpp Table_RobotoCondensed_Regular_22_4bpp.cpp Table_RobotoCondensed_Regular_38_4bpp.cpp Table_RobotoCondensed_Regular_54_4bpp.cpp
  group Application/User/TouchGFX/generated/gui_generated/common
    ../Gui/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/containers
    ../Gui/generated/gui_generated/src/containers/: McuLoadWidgetBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/controls_screen
    ../Gui/generated/gui_generated/src/controls_screen/: ControlsViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/game2048_screen
    ../Gui/generated/gui_generated/src/game2048_screen/: Game2048ViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/game2d_screen
    ../Gui/generated/gui_generated/src/game2d_screen/: Game2DViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/graphics_effect_screen
    ../Gui/generated/gui_generated/src/graphics_effect_screen/: graphics_effectViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/homeautomation_screen
    ../Gui/generated/gui_generated/src/homeautomation_screen/: HomeAutomationViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/mainmenuanimatingbuttons_screen
    ../Gui/generated/gui_generated/src/mainmenuanimatingbuttons_screen/: MainMenuAnimatingButtonsViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/mainmenucarousel_screen
    ../Gui/generated/gui_generated/src/mainmenucarousel_screen/: MainMenuCarouselViewBase.cpp
  group Application/User/TouchGFX/generated/gui_generated/settings_screen
    ../Gui/generated/gui_generated/src/settings_screen/: SettingsViewBase.cpp
  group Application/User/TouchGFX/generated/images
    ../Gui/generated/images/src/: BitmapDatabase.cpp
  group Application/User/TouchGFX/generated/images/AnimatingButtonsMenu
    ../Gui/generated/images/src/AnimatingButtonsMenu/: Animating_buttons_background.cpp Animating_buttons_full_table_shadow_bottom.cpp Animating_buttons_full_table_shadow_left.cpp Animating_buttons_full_table_shadow_right.cpp animating_buttons_menu_icons_2048_tiny.cpp animating_buttons_menu_icons_controls_tiny.cpp animating_buttons_menu_icons_game_2d_tiny.cpp animating_buttons_menu_icons_graphics_effect_tiny.cpp animating_buttons_menu_icons_home_automation_tiny.cpp animating_buttons_menu_icons_settings_tiny.cpp Animating_buttons_table_element_shadow.cpp
  group Application/User/TouchGFX/generated/images/CarouselMenu
    ../Gui/generated/images/src/CarouselMenu/: carousel_background.cpp carousel_menu_icons_2048_large.cpp carousel_menu_icons_2048_medium.cpp carousel_menu_icons_2048_small.cpp carousel_menu_icons_controls_large.cpp carousel_menu_icons_controls_medium.cpp carousel_menu_icons_controls_small.cpp carousel_menu_icons_game_2d_large.cpp carousel_menu_icons_game_2d_medium.cpp carousel_menu_icons_game_2d_small.cpp carousel_menu_icons_graphics_effect_large.cpp carousel_menu_icons_graphics_effect_medium.cpp carousel_menu_icons_graphics_effect_small.cpp carousel_menu_icons_home_automation_large.cpp carousel_menu_icons_home_automation_medium.cpp carousel_menu_icons_home_automation_small.cpp carousel_menu_icons_settings_large.cpp carousel_menu_icons_settings_medium.cpp carousel_menu_icons_settings_small.cpp
  group Application/User/TouchGFX/generated/images/Controls
    ../Gui/generated/images/src/Controls/: board_image.cpp control_line_indicator.cpp controls_2dots.cpp controls_3dots.cpp controls_background.cpp dot_indicator_.cpp dot_indicator_highlighted.cpp icon_brightness_large.cpp icon_brightness_small.cpp menu_icon.cpp menu_icon_pressed.cpp slider.cpp slider_full.cpp slider_knop.cpp value_indicator_arrow.cpp value_indicator_circle.cpp value_indicator_glow.cpp value_indicator_wheel.cpp
  group Application/User/TouchGFX/generated/images/Game2048
    ../Gui/generated/images/src/Game2048/: auto_play_button.cpp auto_play_button_pressed.cpp game_2048_background.cpp game_2048_dot_off.cpp game_2048_dot_on.cpp game_2048_game_over.cpp game_2048_menu_button.cpp game_2048_menu_button_pressed.cpp game_2048_you_win.cpp how_to_play_00.cpp how_to_play_01.cpp how_to_play_02.cpp how_to_play_background.cpp how_to_play_button.cpp how_to_play_button_pressed.cpp how_to_play_close_button.cpp new_game_button.cpp new_game_button_pressed.cpp tile_0002.cpp tile_0004.cpp tile_0008.cpp tile_0016.cpp tile_0032.cpp tile_0064.cpp tile_0128.cpp tile_0256.cpp tile_0512.cpp tile_1024.cpp tile_2048.cpp
  group Application/User/TouchGFX/generated/images/Game2D
    ../Gui/generated/images/src/Game2D/: collectible_item_00.cpp collectible_item_01.cpp collectible_item_02.cpp collectible_item_03.cpp collectible_item_04.cpp collectible_item_05.cpp collectible_item_06.cpp collectible_item_07.cpp collectible_item_08.cpp collectible_item_09.cpp game2d_background.cpp game2d_fly_button.cpp game2d_fly_button_pressed.cpp game2d_ground.cpp game2d_hw_button_off.cpp game2d_hw_button_off_pressed.cpp game2d_hw_button_on.cpp game2d_hw_button_on_pressed.cpp game2d_menu_button.cpp game2d_menu_button_pressed.cpp game2d_st_button_off.cpp game2d_st_button_off_pressed.cpp game2d_st_button_on.cpp game2d_st_button_pressed.cpp game2d_topLeaves.cpp game2d_TreeTops.cpp game_2d_frame_background.cpp sphere1.cpp sprite_00.cpp sprite_01.cpp sprite_02.cpp sprite_03.cpp sprite_04.cpp sprite_05.cpp sprite_06.cpp sprite_07.cpp sprite_08.cpp sprite_09.cpp
  group Application/User/TouchGFX/generated/images/GraphicsEffect
    ../Gui/generated/images/src/GraphicsEffect/: blue_slider_vertical_small_indicators_slider3_vertical_round_nob.cpp blue_slider_vertical_small_slider3_vertical_round_back.cpp blue_slider_vertical_small_slider3_vertical_round_fill.cpp box00.cpp box01.cpp
  group Application/User/TouchGFX/generated/images/HomeAutomation
    ../Gui/generated/images/src/HomeAutomation/: blinds_icon_32.cpp home_automation_background.cpp home_back_button.cpp home_back_button_pressed.cpp home_room_image_00.cpp home_room_image_01.cpp home_room_image_02.cpp home_room_image_03.cpp home_room_image_04.cpp home_room_image_05.cpp home_room_image_06.cpp home_room_image_07.cpp home_room_image_08.cpp home_room_image_09.cpp home_room_selected_light.cpp home_room_selected_lock.cpp lights_icon_32.cpp lock_icon_32.cpp main_button_blinds.cpp main_button_blinds_pressed.cpp main_button_light.cpp main_button_light_pressed.cpp main_button_security.cpp main_button_security_pressed.cpp main_button_statistics.cpp main_button_statistics_pressed.cpp statistics_gradient_blue.cpp statistics_gradient_blue_line.cpp statistics_gradient_green.cpp statistics_gradient_green_line.cpp statistics_gradient_red.cpp statistics_gradient_red_line.cpp statistics_lower.cpp statistics_upper.cpp
  group Application/User/TouchGFX/generated/images/HomeAutomation/login
    ../Gui/generated/images/src/HomeAutomation/login/: login_node_00.cpp login_node_01.cpp login_node_02.cpp login_node_03.cpp login_node_04.cpp login_node_05.cpp login_node_06.cpp login_node_07.cpp login_node_08.cpp login_node_09.cpp login_node_10.cpp login_node_11.cpp login_node_12.cpp login_node_13.cpp login_node_14.cpp login_node_15.cpp login_node_16.cpp login_node_17.cpp login_node_18.cpp login_node_19.cpp login_node_20.cpp login_node_21.cpp login_node_22.cpp login_node_23.cpp login_node_24.cpp login_node_25.cpp login_node_26.cpp login_node_27.cpp login_node_28.cpp
  group Application/User/TouchGFX/generated/images/Settings
    ../Gui/generated/images/src/Settings/: blue_glow.cpp clock_00_background.cpp clock_00_hour_hand.cpp clock_00_minute_hand.cpp clock_00_second_hand.cpp clock_01_background.cpp clock_01_hour_hand.cpp clock_01_minute_hand.cpp clock_01_second_hand.cpp clock_02_background.cpp clock_02_hour_hand.cpp clock_02_minute_hand.cpp clock_02_second_hand.cpp clock_settings_AM.cpp clock_settings_circle.cpp clock_settings_circleSelected.cpp clock_settings_colon.cpp clock_settings_PM.cpp date_picker_background.cpp date_picker_bar.cpp date_picker_shadow_bottom.cpp date_picker_shadow_top.cpp settings_button.cpp settings_button_pressed.cpp settings_calendar.cpp settings_done.cpp settings_done_pressed.cpp settings_next.cpp settings_next_pressed.cpp
  group Application/User/TouchGFX/generated/texts
    ../Gui/generated/texts/src/: LanguageGbr.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/User/TouchGFX/gui/common
    ../Gui/gui/src/common/: Carousel.cpp CircularValueIndicator.cpp DotIndicator.cpp FrontendApplication.cpp SwipeContainer.cpp ZoomAnimationBox.cpp
  group Application/User/TouchGFX/gui/containers
    ../Gui/gui/src/containers/: McuLoadWidget.cpp
  group Application/User/TouchGFX/gui/controls_screen
    ../Gui/gui/src/controls_screen/: ControlsPresenter.cpp ControlsView.cpp
  group Application/User/TouchGFX/gui/game2048_screen
    ../Gui/gui/src/game2048_screen/: Game2048Presenter.cpp Game2048View.cpp GameBoard.cpp
  group Application/User/TouchGFX/gui/game2d_screen
    ../Gui/gui/src/game2d_screen/: CollectibleItem.cpp Game2DPresenter.cpp Game2DView.cpp ParallaxBackground.cpp
  group Application/User/TouchGFX/gui/graphics_effect_screen
    ../Gui/gui/src/graphics_effect_screen/: graphics_effectPresenter.cpp graphics_effectView.cpp
  group Application/User/TouchGFX/gui/homeautomation_screen
    ../Gui/gui/src/homeautomation_screen/: Graph.cpp GraphLine.cpp HomeAutomationPresenter.cpp HomeAutomationView.cpp LoginWidget.cpp PainterRGB565TiledBitmap.cpp PainterRGB888TiledBitmap.cpp RoomControl.cpp RoomControlAdjustable.cpp RoomControlToggle.cpp RoomControlWheel.cpp StatisticsContainer.cpp
  group Application/User/TouchGFX/gui/mainmenuanimatingbuttons_screen
    ../Gui/gui/src/mainmenuanimatingbuttons_screen/: MainMenuAnimatingButtonsPresenter.cpp MainMenuAnimatingButtonsView.cpp
  group Application/User/TouchGFX/gui/mainmenucarousel_screen
    ../Gui/gui/src/mainmenucarousel_screen/: MainMenuCarouselPresenter.cpp MainMenuCarouselView.cpp
  group Application/User/TouchGFX/gui/model
    ../Gui/gui/src/model/: Model.cpp
  group Application/User/TouchGFX/gui/settings_screen
    ../Gui/gui/src/settings_screen/: AnalogClockWithSetTimeFunctionality.cpp ClockSelectorContainer.cpp DatePicker.cpp DateSelectorContainer.cpp SettingsPresenter.cpp SettingsView.cpp TimeSettingContainer.cpp WheelSelector.cpp
  group Drivers/BSP/Components/CS42L51
    ../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
  group Drivers/BSP/Components/FT5336
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
  group Drivers/BSP/Components/GT911
    ../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
  group Drivers/BSP/Components/IS42S32800J
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
  group Drivers/BSP/Components/MFXSTM32L152
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
  group Drivers/BSP/Components/MX25LM51245G
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/STM32H7B3I_EVAL
    ../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_io.c stm32h7b3i_eval_ospi.c stm32h7b3i_eval_sdram.c stm32h7b3i_eval_ts.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_nor.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_sram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c
  group Middleware/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middleware/FreeRTOS/CMSIS_RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middleware/FreeRTOS/MemMgr
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middleware/FreeRTOS/Portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middleware/TouchGFX/Lib
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/IAR8.x/: touchgfx_core_release.a
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group Middleware/TouchGFX/OS
    ../../../../../Middlewares/ST/TouchGFX/touchgfx/os/: OSWrappers_cmsis.cpp
  group Middleware/TouchGFX/Target
    ../Gui/target/: BoardConfiguration.cpp Buttons.cpp GPIO.cpp KeySampler.cpp STM32H7DMA.cpp STM32H7HAL.cpp STM32H7Instrumentation.cpp STM32H7TouchController.cpp
target TouchGFX-STM32H7B3I-EVAL_OoB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H7B3LIHxQ STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.2
  cpu: as above
  output: TouchGFX-STM32H7B3I-EVAL_OoB_V1.0.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,USE_PWR_DIRECT_SMPS_SUPPLY,STM32H7B3xxQ,USE_STM32H7B3I_EVAL,USE_BPP=16,ST,USE_FLOATING_POINT,USE_STM32H7B3I_EVAL_OOB
  c misc: --diag_suppress 1300
  c include: as above
  asm include: ../Config
  memory RVCT4: ROM 0x8020000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: TouchGFX-STM32H7B3I-EVAL_OoB\Exe\TouchGFX-STM32H7B3I-EVAL_OoB_V1.0.sct
software components: CMSIS:CORE 4.3.0
