# IAR project STemWin.ewp, settings and files
configuration STemWin-STM32H7B3I-EVAL (ARM)
  General.OGChipSelectEditMenu: STM32H7B3LI-Q ST STM32H7B3LI-Q
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H7B3xxQ; USE_STM32H7B3I_EVAL; USE_TS_INT; USE_SDCARD
  ICCARM.CCIncludePath2: ..\Config; ..\Core\Inc; ..\Gui\STemWin_Addons; ..\Gui\Target; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\..\..\Drivers\STM32H7xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM32H7B3I-EVAL; ..\..\..\..\..\Drivers\BSP\Components; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\..\..\Middlewares\Third_Party\FatFs\src\drivers; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include; ..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: ..\Binary\STemWin-STM32H7B3I-EVAL_V1.1.0.hex
  ILINK.IlinkOutputFile: STemWin-STM32H7B3I-EVAL_V1.0.0.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08000000
  ILINK.IlinkIcfFile: stm32h7xx_STemWin.icf
  ILINK.IlinkExtraOptions: --image_input ..\Core\Src\assets\stemwin_icon.bmp,demo_icon,demo_icon_section,32; --keep demo_icon; --image_input ..\Core\Src\assets\stemwin_logo.bmp,demo_logo,demo_logo_section,32; --keep demo_logo
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STemWin-STM32H7B3I-EVAL_OoB (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_PWR_DIRECT_SMPS_SUPPLY; USE_HAL_DRIVER; STM32H7B3xxQ; USE_STM32H7B3I_EVAL; USE_STM32H7B3I_EVAL_OOB; USE_TS_INT; USE_SDCARD
  OBJCOPY.OOCOutputFile: ..\Binary\STemWin-STM32H7B3I-EVAL_OoB_V1.1.0.hex
  ILINK.IlinkOutputFile: STemWin-STM32H7B3I-EVAL_OoB_V1.0.0.out
  ILINK.IlinkConfigDefines: __C_START_ADDR=0x08060000
  group Application/EWARM
    ./: startup_stm32h7b3xxq.s
  group Application/User/Core
    ../Core/Src/: k_bsp.c k_menu.c k_module.c main.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c storage.c system_stm32h7xx.c
  group Application/User/Gui/games
    ../Gui/Core/games/: rocket_game_win.c
  group Application/User/Gui/games/generated
    ../Gui/Core/games/generated/: background_game.c
  group Application/User/Gui/games/generated/coins
    ../Gui/Core/games/generated/coins/: coin1.c coin10.c coin11.c coin12.c coin13.c coin2.c coin3.c coin4.c coin5.c coin6.c coin7.c coin8.c coin9.c
  group Application/User/Gui/games/generated/gameover_screen
    ../Gui/Core/games/generated/gameover_screen/: game_over.c replay_button.c rocket_down1_game_over.c rocket_down2_game_over.c rocket_down_game_over.c score.c score_shape_game_over.c
  group Application/User/Gui/games/generated/objects
    ../Gui/Core/games/generated/objects/: comet.c moon.c planet1.c planet2.c planet3.c
  group Application/User/Gui/games/generated/parallax
    ../Gui/Core/games/generated/parallax/: mountains1.c mountains2.c sky2.c
  group Application/User/Gui/games/generated/play_screen
    ../Gui/Core/games/generated/play_screen/: game_title.c play_button.c
  group Application/User/Gui/games/generated/rocket
    ../Gui/Core/games/generated/rocket/: rocket.c
  group Application/User/Gui/games/generated/score
    ../Gui/Core/games/generated/score/: goldCoin.c scoreShape.c
  group Application/User/Gui/generated
    ../Core/Src/generated/: Arial18.c ArialRoundedBold18.c ArialRoundedBold20.c ArialRoundedBold24.c
  group Application/User/Gui/generated/menu
    ../Core/Src/: k_modules_res.c
  group Application/User/Gui/generated/menu/idle
    ../Core/Src/generated/menu/idle/: graphic_effects_idle.c video_game_idle.c
  group Application/User/Gui/graphic_effect
    ../Gui/Core/graphic_effect/: fatfs_storage.c filtring.c graphic_effects_win.c
  group Application/User/Gui/graphic_effect/generated
    ../Gui/Core/graphic_effect/generated/buttons/: apply_filter.c apply_filter_pressed.c cpu_load_background.c edge_detection.c edge_detection_gray.c motion_blur.c motion_blur_gray.c next.c next_gray.c next_pressed.c previous.c previous_gray.c previous_pressed.c raising.c raising_gray.c reset.c reset_gray.c reset_pressed.c sharpening.c sharpening_gray.c smoothing.c smoothing_gray.c
    ../Gui/Core/graphic_effect/: graphic_effects_res.c
  group Application/User/Gui/settings
    ../Gui/Core/settings/: settings_win.c
  group Application/User/Gui/settings/generated
    ../Gui/Core/settings/generated/: Board.c Chip.c Firmware.c Speed.c
  group Application/User/Utilities
    ../../../../../Utilities/CPU/: cpu_utils.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/ft5336/: ft5336.c ft5336_reg.c
    ../../../../../Drivers/BSP/Components/gt911/: gt911.c gt911_reg.c
    ../../../../../Drivers/BSP/Components/is42s32800j/: is42s32800j.c
    ../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../Drivers/BSP/Components/mx25lm51245g/: mx25lm51245g.c
  group Drivers/BSP/STM32H7B3I-EVAL
    ../../../../../Drivers/BSP/STM32H7B3I-EVAL/: stm32h7b3i_eval.c stm32h7b3i_eval_bus.c stm32h7b3i_eval_io.c stm32h7b3i_eval_ospi.c stm32h7b3i_eval_sd.c stm32h7b3i_eval_sdram.c stm32h7b3i_eval_ts.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hcd.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_ospi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Middlewares/FatFs/Core
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/Drivers
    ../Core/Src/: sd_diskio.c
  group Middlewares/FatFs/Options
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Middlewares/FreeRTOS/CMSIS-RTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/FreeRTOS/portable
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s
  group Middlewares/STemWin/Library
    ../../../../../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc32_ARGB.a
  group Middlewares/STemWin/OS
    ../../../../../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/STemWin/ST_GUI_Addons
    ../Gui/STemWin_Addons/: STemWin_Addons_CM7_wc32.a
  group Middlewares/STemWin/Target
    ../Gui/Target/: GUIConf.c LCDConf.c
