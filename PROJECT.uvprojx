# Keil uVision project PROJECT.uvprojx, settings and files
target PROJECT (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: PROJECT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3
  c define: STM32H743xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER,DEBUG=1
  c include: .\USER;.\STM32Cube_FW_H7_V1.12.0\Drivers\STM32H7xx_HAL_Driver\Inc;.\STM32Cube_FW_H7_V1.12.0\Drivers\CMSIS\Include;.\STM32Cube_FW_H7_V1.12.0\Drivers\CMSIS\Device\ST\STM32H7xx\Include;.\DRIVER;.\DRIVER\DRIVER_LED;.\DRIVER\DRIVER_KEY;.\SEGGER_RTT\Config;.\SEGGER_RTT\RTT;.\CIRCULAR_BUFFER\src;.\CIRCULAR_BUFFER\port;.\MEM_MANGE;.\DRIVER\BASE_TIMER6;.\DRIVER\PWM_TIMER2;.\DRIVER\PWM_IN_TIMER5;.\DRIVER\DRIVER_EEPROM;.\DRIVER\PWM_TIMER1;.\DRIVER\QSPI_FLASH;.\FATFS;.\DRIVER\LPTIMER;.\DRIVER\FMC_LCD;.\LVGL;.\LVGL\src;.\LVGL\examples\porting;.\LVGL\demos;.\LVGL\demos\benchmark;.\DRIVER\BDMAMUX_PWM;.\DRIVER\DMA1MUX_PWM;.\DRIVER\USART1_DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\OUTFILES\PROJECT.sct
  group START
    ./STM32Cube_FW_H7_V1.12.0/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group CMSIS
    ./STM32Cube_FW_H7_V1.12.0/Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group LIB
    ./STM32Cube_FW_H7_V1.12.0/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cordic.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dfsdm_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dsi.c stm32h7xx_hal_dts.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_fmac.c stm32h7xx_hal_gfxmmu.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_msp_template.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_ospi.c stm32h7xx_hal_otfdec.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pssi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_ramecc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rng_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdio.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_smbus_ex.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_timebase_rtc_alarm_template.c stm32h7xx_hal_timebase_rtc_wakeup_template.c stm32h7xx_hal_timebase_tim_template.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_adc.c stm32h7xx_ll_bdma.c stm32h7xx_ll_comp.c stm32h7xx_ll_cordic.c stm32h7xx_ll_crc.c stm32h7xx_ll_crs.c stm32h7xx_ll_dac.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_dma.c stm32h7xx_ll_dma2d.c stm32h7xx_ll_exti.c stm32h7xx_ll_fmac.c stm32h7xx_ll_fmc.c stm32h7xx_ll_gpio.c stm32h7xx_ll_hrtim.c stm32h7xx_ll_i2c.c stm32h7xx_ll_lptim.c stm32h7xx_ll_lpuart.c stm32h7xx_ll_mdma.c stm32h7xx_ll_opamp.c stm32h7xx_ll_pwr.c stm32h7xx_ll_rcc.c stm32h7xx_ll_rng.c stm32h7xx_ll_rtc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_spi.c stm32h7xx_ll_swpmi.c stm32h7xx_ll_tim.c stm32h7xx_ll_usart.c stm32h7xx_ll_usb.c stm32h7xx_ll_utils.c
  group DRIVER
    ./DRIVER/DRIVER_LED/: drv_led.c drvp_led.c
    ./DRIVER/DRIVER_KEY/: drv_key.c drvp_key.c
    ./DRIVER/BASE_TIMER6/: base_timer6.c
    ./DRIVER/PWM_TIMER2/: pwm_timer2.c
    ./DRIVER/PWM_IN_TIMER5/: pwm_in_timer5.c
    ./DRIVER/PWM_TIMER1/: pwm_timer1.c
    ./DRIVER/DRIVER_EEPROM/: drv_eeprom.c drvp_eeprom.c
    ./DRIVER/QSPI_FLASH/: qspi_flash.c
    ./DRIVER/LPTIMER/: drv_lptimer2.c
    ./DRIVER/FMC_LCD/: drv_fmc_lcd.c drvp_fmc_lcd.c
    ./DRIVER/BDMAMUX_PWM/: bdmamux_pwm.c
    ./DRIVER/DMA1MUX_PWM/: dma1mux_pwm.c
    ./DRIVER/USART1_DMA/: usart1_dma.c
  group CYCLE_BUF/PORT
    ./CIRCULAR_BUFFER/port/: port.c
  group CYCLE_BUF/SRC
    ./CIRCULAR_BUFFER/src/: circular_buffer.c
  group MEM_MANGE
    ./MEM_MANGE/: sram_d2_malloc.c
  group USER
    ./USER/: main.c stm32h7xx_it.c
  group SEGGER_RTT
    ./SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group SEGGER_HARDFAULT
    ./HardFaultHandler/: HardFaultHandler.s SEGGER_HardFaultHandler.c
  group LVGL
    ./LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ./LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ./LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ./LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ./LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ./LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ./LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ./LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ./LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ./LVGL/src/extra/: lv_extra.c
    ./LVGL/src/extra/layouts/flex/: lv_flex.c
    ./LVGL/src/extra/layouts/grid/: lv_grid.c
    ./LVGL/src/extra/libs/bmp/: lv_bmp.c
    ./LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ./LVGL/src/extra/libs/freetype/: lv_freetype.c
    ./LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ./LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ./LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ./LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ./LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ./LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ./LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ./LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ./LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ./LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ./LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ./LVGL/src/extra/others/monkey/: lv_monkey.c
    ./LVGL/src/extra/others/msg/: lv_msg.c
    ./LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ./LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ./LVGL/src/extra/themes/default/: lv_theme_default.c
    ./LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ./LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ./LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./LVGL/src/extra/widgets/chart/: lv_chart.c
    ./LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ./LVGL/src/extra/widgets/led/: lv_led.c
    ./LVGL/src/extra/widgets/list/: lv_list.c
    ./LVGL/src/extra/widgets/menu/: lv_menu.c
    ./LVGL/src/extra/widgets/meter/: lv_meter.c
    ./LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ./LVGL/src/extra/widgets/span/: lv_span.c
    ./LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ./LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ./LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ./LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ./LVGL/src/extra/widgets/win/: lv_win.c
    ./LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ./LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL_PORT
    ./LVGL/examples/porting/: lv_port_disp_template.c lv_port_disp_template.h
  group LVGL_DEMO
    ./LVGL/demos/benchmark/: lv_demo_benchmark.c
    ./LVGL/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
  group FATFS
    ./FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
software components: Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
